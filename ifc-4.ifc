Properties of the parts of a building model (IFC4)

# File
Description: Raumtemperaturregler, Heizen/Kühlen, Aufputz, 24 VAC/VDC, Ausgang 0…10 V / 10…0 V, 2-/4-Rohr, Schalter Aus/Komfort/ECO, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: DA451600, Raumtemperaturregler, Heizen/Kühlen, Aufputz, 24 VAC/VDC, Ausgang 0…10 V / 10…0 V, 2-/4-Rohr, Schalter Aus/Komfort/ECO
In: Raum
Description: Elektronischer Aufputz-Klimaregler zur Heiz-/Kühlregelung in 2- und 4-Rohr-Leitungssysteme für Hotel-, Wohn und Geschäftsräume. Zur Ansteuerung von stetigen Ventilstellantrieben, sowohl stromlos geschlossen als auch stromlos offen, entwickelt. Mit dem Schalter kann zwischen den Betriebsarten Aus/Komfort/ECO gewählt werden. Durch die Möglichkeit der Taupunktüberwachung besonders geeignet zur Kühldeckenregelung. Um die Trägheit von Regelstrecken mit Kühldecken zu kompensieren, verfügt das Gerät über einen Temperaturfühlereingang zur Aufschaltung eines externen Strahlungsfühlers (optional). Als Behördenvariante, bei der der Regler für Unbefugte unerreichbar sein soll, kann der externe Fühler auch als Raumfühler (optional) ausgeführt werden. Mit einem internem Poti kann die Verwendung des internen, des externen oder die Verwendung beider Fühler mit einer einstellbaren Wichtung gewählt werden. Kontakteingänge für ECO-Funktion und AUS (Frostschutz).; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: DA451600; ModelLabel: KTRVB-052.245; GlobalTradeItemNumber: 4050528028259; ProductURL: https://alre.de/produkt_DA451600
Pset_Specification - NominalLength: 0.0834 m; NominalWidth: 0.0783 m; NominalDepth: 0.0255 m; NetWeight: 0.083
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: weiß; Breite: 78.3; Höhe: 83.4; Tiefe: 25.5; RAL-Nummer: 9010; Anschluss: sonstige; Art der Spannungsversorgung: 24 V AC; Messbereich: 13; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Widerstandssensor; Schutzart (NEMA): sonstige; Mit Empfänger: no; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 1; Temperatur ablesbar: no; Max. Kontaktbelastung: 0.005; Differenzwert: 0; Sensor extern: no; Thermische Rückkopplung: ohne; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-DA451600.pdf
